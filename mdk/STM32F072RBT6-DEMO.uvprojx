# Keil uVision project STM32F072RBT6-DEMO.uvprojx, settings and files
target STM32F072RBT6-P1 (ARM-ADS)
  device: STM32F072RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: iflash_STM32F0_P1 +hex
  AfterMake: $KARM\BIN\ELFDWT.EXE "#L" BASEADDRESS(0x08005000)
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 wLevel=2
  c define: USE_STDPERIPH_DRIVER,   STM32F072,   IFLASH_STM32F0_P1
  c misc: --C99
  c include: ..\;..\..\;..\lib;..\lib\inc;..\lib\src;..\startup;..\user;..\stm32f072rbt6
  library: MicroLIB
  memory RVCT4: ROM 0x8005000 size 0x1b000
  memory RVCT9: RAM 0x200000c0 size 0x3f40
  link misc: --diag_suppress=L6329
  group stm32f072rbt6
    ../stm32f072rbt6/: system_stm32f0xx.c stm32f0xx_it.c
  group startup
    ../startup/: startup_stm32f072.s
  group lib
    ../lib/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group user
    ../user/: app_types.h app_p1.h app_p2.h main.c main.h app_led.c app_led.h app_power.c app_power.h app_cmd.c app_cmd.h app_debug.c app_debug.h config.c config.h updata.c updata.h app_pwm.c app_pwm.h app_kbd.c app_kbd.h app_uart.c app_uart.h app_usart.c app_usart.h trace.c app_wdt.c app_wdt.h app_adc.c app_adc.h app_spi.c app_spi.h MX25L1602Drv.c MX25L1602Drv.h
  group usb
    ../usb/src/: stm32f0xx_hal_pcd.c stm32f0xx_hal_pcd_ex.c usb.c usbd_cdc.c usbd_cdc_interface.c usbd_conf.c usbd_core.c usbd_ctlreq.c usbd_desc.c usbd_ioreq.c
